# Keil uVision project QRcode.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: QRcode +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\driver;.\config
  group Source Group 1
    ./driver/: uart.c delay.c lcd12864.c timer.c key.c
    ./: main.c QRcoder.c
